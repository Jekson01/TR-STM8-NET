# IAR project tr_net.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: tr_net.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  group (top)
    ./: buttons.cpp buttons.h crc.cpp crc.h delay.h ds18b20.cpp ds18b20.h hardware.cpp hardware.h hardware_delay.cpp hardware_delay.h ind7seg.cpp ind7seg.h macros.h main.cpp onewire.cpp onewire.h stm_defines.h uart.cpp uart.h
